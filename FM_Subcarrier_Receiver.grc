options:
  parameters:
    author: Gautham Minhas
    description: Simple receiver designed to receive traditional commercial FM signals as well as subcarrier signals at both 67kHz and 92kHz.
    generate_options: qt_gui
    id: FM_Subcarrier_Receiver
    output_language: python
    title: FM/Subcarrier Radio Receiver
  states: {}

blocks:
- name: Volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '2'
    value: '0'
    widget: slider
  states: {}
- name: bb_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: '"Baseband Gain"'
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '50'
    value: '10'
  states: {}
- name: bool_subcarrier
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 2, 0, 1, 1
    label: '"FM/Subcarrier"'
    label0: FM Audio
    label1: Subcarrier Audio
    num_opts: '2'
    option1: '1'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: centre_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: '"Station Frequency"'
    orient: Qt.Horizontal
    start: int(87.9e6)
    step: int(200e3)
    stop: int(107.9e6)
    value: int(100.1e6)
  states: {}
- name: quad_rate
  id: variable
  parameters:
    value: int(250E3)
  states: {}
- name: raw_samp_rate
  id: variable
  parameters:
    value: int(2E6)
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: '"RF Gain"'
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '40'
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(48e3)
  states: {}
- name: station_bandwidth
  id: variable
  parameters:
    value: int(200e3)
  states: {}
- name: subcarrier_freq
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 2, 1, 1, 1
    label: '"Subcarrier Frequency"'
    label0: 67k
    label1: 92k
    num_opts: '2'
    option1: '92000'
    orient: Qt.QHBoxLayout
    type: int
    value: '67000'
    widget: radio_buttons
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: quad_rate
    max_dev: 5e3
    quad_rate: quad_rate
    tau: '75e-6'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: quad_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '5'
    high_cutoff_freq: subcarrier_freq+7e3
    low_cutoff_freq: subcarrier_freq-7e3
    samp_rate: quad_rate
    type: fir_filter_fff
    width: 1e3
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: int(bool_subcarrier == 0)*Volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: int(bool_subcarrier == 1)*Volume
    type: float
  states: {}
- name: display_tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 3, 0, 10, 2
    label0: Waterfall
    label1: Audio Signal Spectrum
    label2: Audio Signal Waveform
    label3: Baseband Signal
    num_tabs: '4'
  states: {}
- name: fm_audio_out
  id: virtual_sink
  parameters:
    stream_id: fm_audio_out
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: subcarrier_freq
    decim: '1'
    samp_rate: quad_rate
    taps: '[1]'
    type: fcf
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    beta: '6.76'
    cutoff_freq: int(station_bandwidth/2)
    decim: int(raw_samp_rate/quad_rate)
    gain: '5'
    samp_rate: raw_samp_rate
    type: fir_filter_ccf
    width: 10e3
    win: firdes.WIN_KAISER
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    beta: '6.76'
    cutoff_freq: 19e3
    decim: '1'
    gain: '1'
    samp_rate: quad_rate
    type: fir_filter_fff
    width: 1e3
    win: firdes.WIN_KAISER
  states: {}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    beta: '6.76'
    cutoff_freq: 5e3
    decim: '1'
    gain: '1'
    samp_rate: quad_rate
    type: fir_filter_fff
    width: '500'
    win: firdes.WIN_KAISER
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: quad_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    gui_hint: display_tab@3:0,0,1,1
    name: '"Baseband Signal"'
    showports: 'True'
    type: float
    wintype: firdes.WIN_HAMMING
    ymin: '-160'
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    gui_hint: display_tab@1:1,0,3,1
    name: '"Audio signal spectrum"'
    showports: 'True'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: display_tab@2:1,0,3,1
    label1: ''
    name: '"Audio signal time"'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: raw_samp_rate
    fc: centre_freq
    fftsize: '1024'
    gui_hint: display_tab@0:1,0,3,1
    name: '"FM Modulated RF Signal"'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: quad_rate
    interp: samp_rate
    taps: ''
    type: fff
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: bb_gain
    dc_offset_mode0: '2'
    freq0: centre_freq
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: '20'
    iq_balance_mode0: '2'
    sample_rate: raw_samp_rate
    sync: sync
    type: fc32
  states: {}
- name: station_output
  id: virtual_source
  parameters:
    stream_id: Demod_signal
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: FM_signal
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: Demod_signal
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: audio_signal
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: subcarrier_audio_out
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: FM_signal
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: audio_signal
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: fm_audio_out
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: subcarrier_audio_out
  states: {}

connections:
- [analog_nbfm_rx_0, '0', low_pass_filter_0_0_0, '0']
- [analog_wfm_rcv_0, '0', band_pass_filter_0, '0']
- [analog_wfm_rcv_0, '0', low_pass_filter_0_0, '0']
- [analog_wfm_rcv_0, '0', virtual_sink_0_0, '0']
- [band_pass_filter_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_add_xx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '1']
- [freq_xlating_fir_filter_xxx_0, '0', analog_nbfm_rx_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_0_0, '0', fm_audio_out, '0']
- [low_pass_filter_0_0_0, '0', virtual_sink_2, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [rational_resampler_xxx_0, '0', virtual_sink_1, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']
- [rtlsdr_source_0, '0', virtual_sink_0, '0']
- [station_output, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [virtual_source_1, '0', qtgui_freq_sink_x_1, '0']
- [virtual_source_1, '0', qtgui_time_sink_x_0, '0']
- [virtual_source_2, '0', blocks_multiply_const_vxx_0, '0']
- [virtual_source_3, '0', blocks_multiply_const_vxx_0_0, '0']

metadata:
  file_format: 1
